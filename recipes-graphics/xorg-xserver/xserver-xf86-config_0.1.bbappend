FILESEXTRAPATHS := "${THISDIR}/${PN}"
