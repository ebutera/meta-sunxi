require linux-mainline.inc

DESCRIPTION = "Mainline Stable Linux kernel"

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

SRC_URI[md5sum] = "199f037b5adc4ca158dc281b60a226f6"
SRC_URI[sha256sum] = "ba4a11e93896305835c630969cf330ae808b0e43f09b375b510cde1bd0efc036"
